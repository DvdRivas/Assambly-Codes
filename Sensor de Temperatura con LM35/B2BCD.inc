	CBLOCK 

	ENDC

;SUBRUTINA
B2BCD
	MOVF	CL,W
	MOVWF	UNIDAD

SL1	
	MOVLW	D'10'
	SUBWF	UNIDAD,W
	BNC		SL2
	INCF	DECENA
	MOVWF	UNIDAD
	GOTO	SL1
	
SL2	MOVLW	D'10'
	SUBWF	DECENA,W
	BNC		SL3
	INCF	CENTENA
	MOVWF	DECENA
	GOTO	SL2
	
SL3	MOVLW	D'10'
	SUBWF	CENTENA,W
	BNC		SL4
	INCF	MILLAR
	MOVWF	CENTENA
	GOTO	SL3
SL4
	MOVLW	0X00
	CPFSEQ	CH	
	GOTO	RESTART
	GOTO	ENDB2BCD
RESTART
	MOVLW	0XF6
	ADDWF	UNIDAD
	INCF	DECENA
	DECF	CH
	GOTO 	SL1
ENDB2BCD

	RETURN