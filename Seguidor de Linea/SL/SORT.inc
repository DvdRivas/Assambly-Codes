SOR
	MOVF	MEDIA,W
	CPFSLT	CENTENA
	GOTO 	RESTA
	GOTO	SUMA
SUMA
	DCFSNZ	TEMP
	RETURN
	INCF	CL
	BTFSC	STATUS,C
	INCF	CH
	GOTO 	SUMA
RESTA
	DCFSNZ	TEMP
	RETURN
	DECFSZ	CL
	GOTO	RESTA
BORROW
	MOVLW	0X00
	CPFSEQ	CH	
	GOTO	PRESTA
	RETURN
PRESTA
	MOVLW	0XF6
	ADDWF	CL
	DECF	CH
	RETURN